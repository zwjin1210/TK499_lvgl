# Keil uVision project TK499_LTDC.uvprojx, settings and files
target TK499_LTDC (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: TK499_LTDC +hex
  AfterMake: fromelf.exe --bin -o  ..//@L.bin  ./obj/@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __FPU_PRESENT
  c include: ..\CMSIS_and_startup;..\CMSIS_and_startup\CMSIS;.\bsp;..\Hal_lib\inc;.\bsp\LCD;.\bsp\LED;.\bsp\SPI;.\bsp\sys;.\bsp\UART;.\bsp\TK499_Timer;.\bsp\ESP8266;..\lvgl;..\lvgl\lv_core;..\lvgl\lv_draw;..\lvgl\lv_font;..\lvgl\lv_hal;..\lvgl\lv_misc;..\lvgl\lv_widgets;..\lvgl\lv_themes
  memory RVCT4: ROM 0x70020000 size 0x200000
  memory RVCT9: RAM 0x70220000 size 0x5dffff
  group startup
    ../CMSIS_and_startup/: startup_Tk499.s tk499.h sys.c
    ./: readme.txt
  group bsp
    ./bsp/: main.c
    ./bsp/LCD/: LCD.c
    ./bsp/LED/: led.c
    ./bsp/SPI/: spi.c
    ./bsp/UART/: UART.c
    ./bsp/ESP8266/: esp8266.c test.c
    ./bsp/TK499_Timer/: TK499_Timer.c
  group hal_lib
    ../Hal_lib/src/: HAL_gpio.c HAL_rcc.c HAL_tim.c HAL_exti.c HAL_misc.c HAL_uart.c HAL_spi.c
  group lvgl
    ../lvgl/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../lvgl/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../lvgl/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c
    ../lvgl/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../lvgl/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../lvgl/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ../lvgl/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
    ../: lv_conf.h
  group lvgl_example
    ../examples/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c
